FILESEXTRAPATHS_prepend := "${THISDIR}/patches:"
SRC_URI += "file://0001-disable-boot-prompt-on-rpi-devices-connected-serial-.patch"
